# Keil uVision project temp.uvprojx, settings and files
target temp (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: debug
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\core;.\fw\inc;.\lib;.\lib\delay;.\lib\usart;.\user;.\lib\sccb;.\lib\ov7670;.\lib\fifo;.\lib\lcd
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ./user/: main.c
  group fw
    ./fw/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
    ./fw/: system_stm32f10x.c
  group lib
    ./lib/delay/: delay.c
    ./lib/: sys.c
    ./lib/usart/: usart.c
    ./lib/sccb/: sccb.c
    ./lib/ov7670/: ov7670.c
    ./lib/lcd/: ILI93xx.c
  group core
    ./core/: core_cm3.c startup_stm32f10x_hd.s
  group doc
    ./: README.md
